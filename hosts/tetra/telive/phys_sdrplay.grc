options:
  parameters:
    author: Jacek Lipkowski SQ5BPF, Ariana "adryd"
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
    title: SDRPLAY RSP1A Receiver Headless
  states: {}

blocks:
- name: first_decim
  id: variable
  parameters:
    value: '32'
  states: {}
- name: first_port
  id: variable
  parameters:
    value: '42000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '412962500'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: samp_rate/first_decim
  states: {}
- name: options_low_pass
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: out_sample_rate
  id: variable
  parameters:
    value: '36000'
  states: {}
- name: ppm_corr
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sdr_gain
  id: variable
  parameters:
    value: '38'
  states: {}
- name: sdr_ifgain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: telive_receiver_channels
  id: variable
  parameters:
    value: '1'
  states: {}
- name: telive_receiver_name
  id: variable
  parameters:
    value: '''SQ5BPF 1-channel headless rx for telive'''
  states: {}
- name: udp_dest_addr
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: udp_packet_size
  id: variable
  parameters:
    value: '1472'
  states: {}
- name: xlate_offset1
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: xlate_offset_fine1
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: bypassed}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: xlate_offset1+xlate_offset_fine1
    decim: first_decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, options_low_pass, options_low_pass*0.2)
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: float(float(if_samp_rate)/float(out_sample_rate))
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: udp_dest_addr
    header: '0'
    payloadsize: udp_packet_size
    port: first_port+1
    send_eof: 'False'
    type: complex
  states: {}
- name: sdrplay3_rsp1a_0
  id: sdrplay3_rsp1a
  parameters:
    AGC: 'True'
    agc_set_point: '-30'
    bandwidth: 1536e3
    biasT: 'False'
    center_freq: freq
    dab_notch_filter: 'True'
    dc_offset_mode: 'False'
    debug_mode: 'True'
    freq_corr: '0'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gR: '0'
    rf_notch_filter: 'True'
    rsp_selector: ''
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'True'
    show_gain_changes: 'False'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: first_port
  states: {}

connections:
- [analog_agc3_xx_0, '0', mmse_resampler_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc3_xx_0, '0']
- [mmse_resampler_xx_0, '0', network_udp_sink_0, '0']
- [sdrplay3_rsp1a_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
